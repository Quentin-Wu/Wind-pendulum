# Keil uVision project WindPendulum.uvprojx, settings and files
target WindPendulum (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usmart +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..\USER;..\FWLIB;..\HARDWARE;..\USMART;..\HARDWARE\uart;..\HARDWARE\key;..\HARDWARE\delay;..\HARDWARE\led;..\HARDWARE\timer;..\HARDWARE\pwm;..\HARDWARE\pid;..\HARDWARE\screen;..\HARDWARE\mpu6050_chuan
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: main.c startup_rvmdk.S control.c
  group HARDWARE
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/led/: led.c
    ../HARDWARE/uart/: myuart.c
    ../HARDWARE/pwm/: mypwm.c
    ../HARDWARE/screen/: screen.c
    ../HARDWARE/pid/: pid.c
    ../HARDWARE/mpu6050_chuan/: mpu6050.c
  group FWLIB
    ../FWLIB/driverlib/rvmdk/: driverlib.lib
    ../FWLIB/driverlib/: gpio.c sysctl.c uart.c timer.c pwm.c interrupt.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
